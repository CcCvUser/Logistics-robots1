# IAR project rt1064.ewp, settings and files
configuration nor_sdram_zf_dtcm (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1064xxx6A NXP MIMXRT1064xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CPU_MIMXRT1064DVL6A; SKIP_SYSCLK_INIT; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; PRINTF_FLOAT_ENABLE=1; SCANF_FLOAT_ENABLE=1; PRINTF_ADVANCED_ENABLE=1; SCANF_ADVANCED_ENABLE=1; FSL_DRIVER_TRANSFER_DOUBLE_WEAK_IRQ=0; USB_STACK_BM; DEBUG; MCUXPRESSO_SDK; SD_ENABLED
  ICCARM.CCDiagSuppress: Pa082,Pa050,GO003,PE550,PE161,PE940,PE111,Pa093,Pe611,Pe997,Pe177
  ICCARM.CCIncludePath2: ..\..\user\inc; ..\..\code; ..\..\..\libraries\sdk\startup\iar; ..\..\..\libraries\sdk\deceive; ..\..\..\libraries\sdk\drives; ..\..\..\libraries\sdk\xip; ..\..\..\libraries\sdk\utilities; ..\..\..\libraries\sdk\utilities\debug_console; ..\..\..\libraries\sdk\utilities\str; ..\..\..\libraries\sdk\cmsis_drivers; ..\..\..\libraries\sdk\components\lists; ..\..\..\libraries\sdk\components\osa; ..\..\..\libraries\sdk\components\serial_manager; ..\..\..\libraries\sdk\components\uart; ..\..\..\libraries\sdk\board; ..\..\..\libraries\components\fatfs\source; ..\..\..\libraries\components\fatfs\source\fsl_sd_disk; ..\..\..\libraries\components\sdmmc; ..\..\..\libraries\components\sdmmc\common; ..\..\..\libraries\components\sdmmc\host\usdhc; ..\..\..\libraries\components\sdmmc\osa; ..\..\..\libraries\components\sdmmc\sd; ..\..\..\libraries\components\usb\device; ..\..\..\libraries\components\usb\include; ..\..\..\libraries\components\usb\phy; ..\..\..\libraries\components\usb\usb_cdc_adapter; ..\..\..\libraries\zf_common; ..\..\..\libraries\zf_driver; ..\..\..\libraries\zf_device; ..\..\..\libraries\sdk\CMSIS\Include; ..\..\..\libraries\sdk\CMSIS\Driver\Include; ..\..\..\libraries\components\CMSIS\Core\Include; ..\..\..\libraries\components\CMSIS\DSP\Include; ..\..\..\libraries\components\CMSIS\DSP\Include\dsp; ..\..\..\libraries\components\CMSIS\DSP\PrivateInclude; ..\..\..\libraries\components\eiq\common\audio; ..\..\..\libraries\components\eiq\common\model; ..\..\..\libraries\components\eiq\tensorflow-lite\examples\common\audio; ..\..\..\libraries\components\eiq\tensorflow-lite\examples\common\model; ..\..\..\libraries\components\eiq\tensorflow-lite\examples\kws; ..\..\..\libraries\components\eiq\tensorflow-lite\third_party\flatbuffers\include; ..\..\..\libraries\components\eiq\tensorflow-lite\third_party\ruy; ..\..\..\libraries\components\eiq\tensorflow-lite\third_party\gemmlowp; ..\..\..\libraries\components\eiq\tensorflow-lite; ..\..\..\libraries\components\eiq\common
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: ..\..\..\Libraries\librares\startup\IAR-ARM
  OBJCOPY.OOCOutputFile: rt1064.srec
  ILINK.IlinkOutputFile: RT106X.out
  ILINK.IlinkKeepSymbols: model_data1
  ILINK.IlinkIcfFile: ..\..\iar\icf\MIMXRT1064xxxxx_flexspi_nor.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\libraries\zf_device\zf_device_config.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group code
    ../../code/: attitude_calculation.c Attitude_Calculation.h beep.c beep.h bmx055.c bmx055.h deal_img.c deal_img.h headfile.h key.c key.h lcd_menu.c lcd_menu.h lcd_show.c lcd_show.h LinkQueue.c LinkQueue.h motor.c motor.h mymooncake.c mymooncake.h pid.c pid.h SEEKFREE_IIC.c SEEKFREE_IIC.h UARTset.c UARTset.h VCAN_VisualScope.c VCAN_VisualScope.h zap.c zap.h
  group components_CMSIS
    ../../../libraries/components/CMSIS/DSP/Source/BasicMathFunctions/: BasicMathFunctions.c
    ../../../libraries/components/CMSIS/DSP/Source/BayesFunctions/: BayesFunctions.c
    ../../../libraries/components/CMSIS/DSP/Source/CommonTables/: CommonTables.c
    ../../../libraries/components/CMSIS/DSP/Source/ComplexMathFunctions/: ComplexMathFunctions.c
    ../../../libraries/components/CMSIS/DSP/Source/ControllerFunctions/: ControllerFunctions.c
    ../../../libraries/components/CMSIS/DSP/Source/DistanceFunctions/: DistanceFunctions.c
    ../../../libraries/components/CMSIS/DSP/Source/FastMathFunctions/: FastMathFunctions.c
    ../../../libraries/components/CMSIS/DSP/Source/FilteringFunctions/: FilteringFunctions.c
    ../../../libraries/components/CMSIS/DSP/Source/InterpolationFunctions/: InterpolationFunctions.c
    ../../../libraries/components/CMSIS/DSP/Source/MatrixFunctions/: MatrixFunctions.c
    ../../../libraries/components/CMSIS/DSP/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
    ../../../libraries/components/CMSIS/DSP/Source/StatisticsFunctions/: StatisticsFunctions.c
    ../../../libraries/components/CMSIS/DSP/Source/SupportFunctions/: SupportFunctions.c
    ../../../libraries/components/CMSIS/DSP/Source/SVMFunctions/: SVMFunctions.c
    ../../../libraries/components/CMSIS/DSP/Source/TransformFunctions/: TransformFunctions.c
  group components_eiq
    ../../../libraries/components/eiq/tensorflow-lite/tensorflow/lite/micro/kernels/: activation_utils.h activations.cpp activations.h activations_common.cpp add.cpp add.h add_common.cpp add_n.cpp arg_min_max.cpp assign_variable.cpp batch_to_space_nd.cpp call_once.cpp cast.cpp ceil.cpp circular_buffer.cpp circular_buffer.h circular_buffer_common.cpp comparisons.cpp concatenation.cpp conv.cpp conv.h conv_common.cpp cumsum.cpp depth_to_space.cpp depthwise_conv.cpp depthwise_conv.h depthwise_conv_common.cpp dequantize.cpp dequantize.h dequantize_common.cpp detection_postprocess.cpp elementwise.cpp elu.cpp ethosu.cpp ethosu.h exp.cpp expand_dims.cpp fill.cpp floor.cpp floor_div.cpp floor_mod.cpp fully_connected.cpp fully_connected.h fully_connected_common.cpp gather.cpp gather_nd.cpp hard_swish.cpp hard_swish.h hard_swish_common.cpp if.cpp kernel_runner.h kernel_util.cpp kernel_util.h l2_pool_2d.cpp l2norm.cpp leaky_relu.cpp leaky_relu.h leaky_relu_common.cpp log_softmax.cpp logical.cpp logical.h logical_common.cpp logistic.cpp logistic.h logistic_common.cpp maximum_minimum.cpp micro_ops.h micro_utils.h mirror_pad.cpp mul.cpp mul.h mul_common.cpp neg.cpp pack.cpp pad.cpp pooling.cpp pooling.h pooling_common.cpp prelu.cpp prelu.h prelu_common.cpp quantize.cpp quantize.h quantize_common.cpp read_variable.cpp reduce.cpp reshape.cpp resize_bilinear.cpp resize_nearest_neighbor.cpp round.cpp shape.cpp slice.cpp softmax.cpp softmax.h softmax_common.cpp space_to_batch_nd.cpp space_to_depth.cpp split.cpp split_v.cpp squeeze.cpp strided_slice.cpp sub.cpp sub.h sub_common.cpp svdf.cpp svdf.h svdf_common.cpp tanh.cpp transpose.cpp transpose_conv.cpp unpack.cpp var_handle.cpp zeros_like.cpp
    ../../../libraries/components/eiq/tensorflow-lite/tensorflow/lite/micro/: all_ops_resolver.cpp all_ops_resolver.h compatibility.h debug_log.cpp debug_log.h fake_micro_context.cpp fake_micro_context.h flatbuffer_utils.cpp flatbuffer_utils.h memory_helpers.cpp memory_helpers.h micro_allocator.cpp micro_allocator.h micro_arena_constants.h micro_context.cpp micro_context.h micro_error_reporter.cpp micro_error_reporter.h micro_graph.cpp micro_graph.h micro_interpreter.cpp micro_interpreter.h micro_mutable_op_resolver.h micro_op_resolver.h micro_profiler.cpp micro_profiler.h micro_resource_variable.cpp micro_resource_variable.h micro_string.cpp micro_string.h micro_time.cpp micro_time.h micro_utils.cpp micro_utils.h recording_micro_allocator.cpp recording_micro_allocator.h recording_simple_memory_allocator.cpp recording_simple_memory_allocator.h simple_memory_allocator.cpp simple_memory_allocator.h
    ../../../libraries/components/eiq/common/audio/: audio.h audio_capture.cpp
    ../../../libraries/components/eiq/tensorflow-lite/examples/kws/: audio_data.h demo_config.h labels.h model_data.h model_ds_cnn_ops_micro.cpp output_postproc.cpp
    ../../../libraries/components/eiq/tensorflow-lite/tensorflow/lite/c/: builtin_op_data.h c_api_types.h common.c common.h
    ../../../libraries/components/eiq/tensorflow-lite/tensorflow/lite/kernels/internal/: common.h compatibility.h cppmath.h max.h min.h portable_tensor.h portable_tensor_utils.h quantization_util.cpp quantization_util.h runtime_shape.h strided_slice_logic.h tensor_ctypes.h types.h
    ../../../libraries/components/eiq/tensorflow-lite/tensorflow/lite/core/api/: error_reporter.cpp error_reporter.h flatbuffer_conversions.cpp flatbuffer_conversions.h op_resolver.cpp op_resolver.h tensor_utils.cpp tensor_utils.h
    ../../../libraries/components/eiq/common/model/: get_top_n.cpp get_top_n.h
    ../../../libraries/components/eiq/tensorflow-lite/tensorflow/lite/micro/memory_planner/: greedy_memory_planner.cpp greedy_memory_planner.h linear_memory_planner.cpp linear_memory_planner.h memory_plan_struct.h micro_memory_planner.h non_persistent_buffer_planner_shim.cpp non_persistent_buffer_planner_shim.h
    ../../../libraries/components/eiq/tensorflow-lite/tensorflow/lite/kernels/: kernel_util.h kernel_utils.cpp op_macros.h padding.h
    ../../../libraries/components/eiq/tensorflow-lite/examples/common/audio/: kws_mfcc.cpp kws_mfcc.hpp mfcc.cpp mfcc.hpp
    ../../../libraries/components/eiq/tensorflow-lite/examples/: model.cpp
    ../../../libraries/components/eiq/tensorflow-lite/tensorflow/lite/schema/: schema_generated.h schema_utils.cpp schema_utils.h
    ../../../libraries/components/eiq/common/: timer.c timer.h
  group components_fatfs
    ../../../libraries/components/fatfs/source/: diskio.c diskio.h ff.c ff.h ffconf.h ffsystem.c ffunicode.c
    ../../../libraries/components/fatfs/source/fsl_sd_disk/: fsl_sd_disk.c fsl_sd_disk.h
  group components_sdmmc
    ../../../libraries/components/sdmmc/sd/: fsl_sd.c fsl_sd.h
    ../../../libraries/components/sdmmc/common/: fsl_sdmmc_common.c fsl_sdmmc_common.h fsl_sdmmc_spec.h
    ../../../libraries/components/sdmmc/host/usdhc/non_blocking/: fsl_sdmmc_host.c
    ../../../libraries/components/sdmmc/host/usdhc/: fsl_sdmmc_host.h
    ../../../libraries/components/sdmmc/osa/: fsl_sdmmc_osa.c fsl_sdmmc_osa.h
    ../../../libraries/components/sdmmc/: sdmmc_config.c sdmmc_config.h
  group components_usb
    ../../../libraries/components/usb/include/: usb.h usb_misc.h usb_spec.h
    ../../../libraries/components/usb/device/: usb_device.h usb_device_dci.c usb_device_dci.h usb_device_ehci.c usb_device_ehci.h
    ../../../libraries/components/usb/usb_cdc_adapter/: usb_device_cdc_acm.c usb_device_cdc_acm.h usb_device_ch9.c usb_device_ch9.h usb_device_class.c usb_device_class.h usb_device_config.h usb_device_descriptor.c usb_device_descriptor.h
    ../../../libraries/components/usb/phy/: usb_phy.c usb_phy.h
  group sdk_device
    ../../../libraries/sdk/board/: board.c board.h clock_config.c clock_config.h
    ../../../libraries/sdk/xip/: evkmimxrt1064_flexspi_nor_config.c EVKMIMXRT1064_FLEXSPI_NOR_CONFIG.h evkmimxrt1064_sdram_ini_dcd.c evkmimxrt1064_sdram_ini_dcd.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
    ../../../libraries/sdk/components/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
    ../../../libraries/sdk/utilities/: fsl_assert.c
    ../../../libraries/sdk/components/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
    ../../../libraries/sdk/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../libraries/sdk/deceive/: fsl_device_registers.h MIMXRT1064.h MIMXRT1064_features.h system_MIMXRT1064.c system_MIMXRT1064.h
    ../../../libraries/sdk/components/osa/: fsl_os_abstraction.h fsl_os_abstraction_bm.c fsl_os_abstraction_bm.h fsl_os_abstraction_config.h
    ../../../libraries/sdk/startup/iar/: startup_MIMXRT1064.s
  group sdk_drivers
    ../../../libraries/sdk/drives/: fsl_adc.c fsl_adc.h fsl_adc_etc.c fsl_adc_etc.h fsl_aipstz.c fsl_aipstz.h fsl_aoi.c fsl_aoi.h fsl_bee.c fsl_bee.h fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_csi.c fsl_csi.h fsl_dcdc.c fsl_dcdc.h fsl_dcp.c fsl_dcp.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_elcdif.c fsl_elcdif.h fsl_enc.c fsl_enc.h fsl_enet.c fsl_enet.h fsl_ewm.c fsl_ewm.h fsl_flexcan.c fsl_flexcan.h fsl_flexcan_edma.c fsl_flexcan_edma.h fsl_flexio.c fsl_flexio.h fsl_flexio_camera.c fsl_flexio_camera.h fsl_flexio_camera_edma.c fsl_flexio_camera_edma.h fsl_flexio_i2c_master.c fsl_flexio_i2c_master.h fsl_flexio_i2s.c fsl_flexio_i2s.h fsl_flexio_i2s_edma.c fsl_flexio_i2s_edma.h fsl_flexio_mculcd.c fsl_flexio_mculcd.h fsl_flexio_mculcd_edma.c fsl_flexio_mculcd_edma.h fsl_flexio_spi.c fsl_flexio_spi.h fsl_flexio_spi_edma.c fsl_flexio_spi_edma.h fsl_flexio_uart.c fsl_flexio_uart.h fsl_flexio_uart_edma.c fsl_flexio_uart_edma.h fsl_flexram.c fsl_flexram.h fsl_flexram_allocate.c fsl_flexram_allocate.h fsl_flexspi.c fsl_flexspi.h fsl_flexspi_edma.c fsl_flexspi_edma.h fsl_gpc.c fsl_gpc.h fsl_gpio.c fsl_gpio.h fsl_gpt.c fsl_gpt.h fsl_iomuxc.h fsl_kpp.c fsl_kpp.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpi2c_edma.c fsl_lpi2c_edma.h fsl_lpspi.c fsl_lpspi.h fsl_lpspi_edma.c fsl_lpspi_edma.h fsl_lpuart.c fsl_lpuart.h fsl_lpuart_edma.c fsl_lpuart_edma.h fsl_ocotp.c fsl_ocotp.h fsl_pit.c fsl_pit.h fsl_pmu.c fsl_pmu.h fsl_pwm.c fsl_pwm.h fsl_pxp.c fsl_pxp.h fsl_qtmr.c fsl_qtmr.h fsl_romapi.c fsl_romapi.h fsl_rtwdog.c fsl_rtwdog.h fsl_sai.c fsl_sai.h fsl_sai_edma.c fsl_sai_edma.h fsl_semc.c fsl_semc.h fsl_snvs_hp.c fsl_snvs_hp.h fsl_snvs_lp.c fsl_snvs_lp.h fsl_spdif.c fsl_spdif.h fsl_spdif_edma.c fsl_spdif_edma.h fsl_src.c fsl_src.h fsl_tempmon.c fsl_tempmon.h fsl_trng.c fsl_trng.h fsl_tsc.c fsl_tsc.h fsl_usdhc.c fsl_usdhc.h fsl_wdog.c fsl_wdog.h fsl_xbara.c fsl_xbara.h fsl_xbarb.c fsl_xbarb.h
  group user_c
    ../../user/src/: isr.c main.c run_kws_model_demo.c
  group user_h
    ../../user/inc/: isr.h run_kws_model_demo.h
  group zf_common
    ../../../libraries/zf_common/: zf_common_clock.c zf_common_clock.h zf_common_debug.c zf_common_debug.h zf_common_fifo.c zf_common_fifo.h zf_common_font.c zf_common_font.h zf_common_function.c zf_common_function.h zf_common_headfile.h zf_common_interrupt.c zf_common_interrupt.h zf_common_typedef.h zf_common_vector.c zf_common_vector.h
  group zf_device
    ../../../libraries/zf_device/: zf_device_absolute_encoder.c zf_device_absolute_encoder.h zf_device_bluetooth_ch9141.c zf_device_bluetooth_ch9141.h zf_device_camera.c zf_device_camera.h zf_device_config.h zf_device_dl1a.c zf_device_dl1a.h zf_device_gps_tau1201.c zf_device_gps_tau1201.h zf_device_icm20602.c zf_device_icm20602.h zf_device_imu660ra.c zf_device_imu660ra.h zf_device_imu963ra.c zf_device_imu963ra.h zf_device_ips114.c zf_device_ips114.h zf_device_ips200.c zf_device_ips200.h zf_device_key.c zf_device_key.h zf_device_mpu6050.c zf_device_mpu6050.h zf_device_mt9v03x.c zf_device_mt9v03x.h zf_device_mt9v03x_flexio.c zf_device_mt9v03x_flexio.h zf_device_oled.c zf_device_oled.h zf_device_ov7725.c zf_device_ov7725.h zf_device_scc8660.c zf_device_scc8660.h zf_device_scc8660_flexio.c zf_device_scc8660_flexio.h zf_device_tft180.c zf_device_tft180.h zf_device_tsl1401.c zf_device_tsl1401.h zf_device_type.c zf_device_type.h zf_device_virtual_oscilloscope.c zf_device_virtual_oscilloscope.h zf_device_wifi_uart.c zf_device_wifi_uart.h zf_device_wireless_uart.c zf_device_wireless_uart.h
  group zf_driver
    ../../../libraries/zf_driver/: zf_driver_adc.c zf_driver_adc.h zf_driver_csi.c zf_driver_csi.h zf_driver_delay.c zf_driver_delay.h zf_driver_encoder.c zf_driver_encoder.h zf_driver_exti.c zf_driver_exti.h zf_driver_flash.c zf_driver_flash.h zf_driver_flexio_csi.c zf_driver_flexio_csi.h zf_driver_gpio.c zf_driver_gpio.h zf_driver_iic.c zf_driver_iic.h zf_driver_pit.c zf_driver_pit.h zf_driver_pwm.c zf_driver_pwm.h zf_driver_romapi.c zf_driver_romapi.h zf_driver_sdio.c zf_driver_sdio.h zf_driver_soft_iic.c zf_driver_soft_iic.h zf_driver_soft_spi.c zf_driver_soft_spi.h zf_driver_spi.c zf_driver_spi.h zf_driver_timer.c zf_driver_timer.h zf_driver_uart.c zf_driver_uart.h zf_driver_usb_cdc.c zf_driver_usb_cdc.h
